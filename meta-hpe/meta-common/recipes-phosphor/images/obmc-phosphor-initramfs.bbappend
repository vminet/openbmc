PACKAGE_INSTALL += "u-boot-fw-utils-gxp recovery-image-validator"
