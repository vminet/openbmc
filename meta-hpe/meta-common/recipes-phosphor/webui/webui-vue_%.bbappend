# This fetches the latest top of tree for the Vue UI
SRCREV = "${AUTOREV}"
